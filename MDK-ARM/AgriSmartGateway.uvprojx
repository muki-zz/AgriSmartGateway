# Keil uVision project AgriSmartGateway.uvprojx, settings and files
target AgriSmartGateway (ARM-ADS)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.1
  cpu: IRAM(0x20000000-0x20004FFF) IROM(0x8000000-0x800FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3") TZ
  output: AgriSmartGateway +hex
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=5 v6LangP=3 wLevel=2
  c define: USE_HAL_DRIVER,STM32F103xB
  c include: ../Core/Inc;../Drivers/STM32F1xx_HAL_Driver/Inc;../Drivers/STM32F1xx_HAL_Driver/Inc/Legacy;../Drivers/CMSIS/Device/ST/STM32F1xx/Include;../Drivers/CMSIS/Include;..\Middleware\Third_Party\RT_Thread\config;..\Middleware\Third_Party\RT_Thread\include;..\Drivers\Lora\app;..\Drivers\Lora\bsp;..\Drivers\Lora\src;..\Middleware\Custom;..\Application
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group Application/MDK-ARM
    ./: startup_stm32f103xb.s
  group Application/User/Core
    ../Core/Src/: main.c gpio.c spi.c usart.c stm32f1xx_it.c stm32f1xx_hal_msp.c
  group Drivers/STM32F1xx_HAL_Driver
    ../Drivers/STM32F1xx_HAL_Driver/Src/: stm32f1xx_hal_gpio_ex.c stm32f1xx_hal_spi.c stm32f1xx_hal.c stm32f1xx_hal_rcc.c stm32f1xx_hal_rcc_ex.c stm32f1xx_hal_gpio.c stm32f1xx_hal_dma.c stm32f1xx_hal_cortex.c stm32f1xx_hal_pwr.c stm32f1xx_hal_flash.c stm32f1xx_hal_flash_ex.c stm32f1xx_hal_exti.c stm32f1xx_hal_uart.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32f1xx.c
  group Code/RT_Thread/board
    ../Middleware/Third_Party/RT_Thread/board/: board.c
  group Code/RT_Thread/config
    ../Middleware/Third_Party/RT_Thread/config/: rtconfig.h
  group Code/RT_Thread/libcpu
    ../Middleware/Third_Party/RT_Thread/libcpu/arm/cortex-m3/: cpuport.c context_rvds.S
  group Code/RT_Thread/src
    ../Middleware/Third_Party/RT_Thread/src/: clock.c components.c cpu.c device.c idle.c ipc.c irq.c kservice.c mem.c memheap.c mempool.c object.c scheduler.c signal.c slab.c thread.c timer.c
  group Code/Drivers/Lora
    ../Drivers/Lora/app/: llcc68_app.c
    ../Drivers/Lora/bsp/: llcc68_hal_stm32.c
    ../Drivers/Lora/src/: llcc68.c llcc68_driver_version.c
  group Code/Miiddleware/Custom
    ../Middleware/Custom/: esp8266.c esp8266.h esp8266_mqtt.c esp8266_mqtt.h
  group Code/Application
    ../Application/: app_config.h app_datahub.h app_lora.c app_lora.h app_mqtt.c app_mqtt.h
software components: CMSIS:CORE 4.3.0
